options:
  parameters:
    generate_options: qt_gui
    id: threeband_filter_summed
    output_language: python
    title: three-band
  states: {}

blocks:
- name: HighPassTaps
  id: variable_high_pass_filter_taps
  parameters:
    cutoff_freq: '4500'
    gain: '1.0'
    samp_rate: samp_rate
    width: '4000'
    win: window.WIN_BLACKMAN
  states: {}
- name: Highzerodb
  id: variable_qtgui_range
  parameters:
    label: '"High zero dB set"'
    start: '0.05'
    step: '0.05'
    stop: '3'
    value: '0.35'
  states: {}
- name: LowPassTaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '200'
    gain: '1.0'
    samp_rate: samp_rate
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: Lowzerodb
  id: variable_qtgui_range
  parameters:
    label: '"Low zero dB set"'
    start: '0.05'
    step: '0.05'
    stop: '5'
    value: '1.8'
  states: {}
- name: expansion
  id: variable_qtgui_range
  parameters:
    label: '"Expansion"'
    min_len: '1'
    start: '1'
    step: '1'
    stop: '50'
    value: '7'
  states: {}
- name: inputGain
  id: variable_qtgui_range
  parameters:
    label: '"Input Gain"'
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: '"Threshold"'
    min_len: '1'
    start: '-0.3'
    step: '0.01'
    stop: '0.3'
    value: '0.0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: expansion
    freq: '10'
    offset: '0'
    phase: '0'
    samp_rate: '10'
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:CARD=sndrpihifiberry,DEV=0
    num_inputs: '2'
    samp_rate: '44100'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:CARD=sndrpihifiberry,DEV=0
    num_outputs: '2'
    samp_rate: '44100'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: threshold
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: threshold
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: threshold
    type: float
  states: {}
- name: blocks_add_xx_0_1_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_0_1_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_0_2
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_0_2_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int((len(LowPassTaps)-1)/2)
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int((len(LowPassTaps)-1)/2)
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: int((len(LowPassTaps)-1)/2)-int((len(HighPassTaps)-1)/2)
    type: float
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: int((len(LowPassTaps)-1)/2)-int((len(HighPassTaps)-1)/2)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: inputGain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: inputGain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: inputGain
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '3.333'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.25'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.25'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '21'
    type: float
  states: {}
- name: customModule_PyRMS_0
  id: customModule_PyRMS
  parameters:
    Cbase: '3.63'
    Cdyn: '1.0'
    Idrain: '33.0'
    Rbase: '50.0'
    k: '500.0'
    samp_rate: '44100'
    zeroDbV: Lowzerodb
  states: {}
- name: customModule_PyRMS_1
  id: customModule_PyRMS
  parameters:
    Cbase: '3.63'
    Cdyn: '1.0'
    Idrain: '33.0'
    Rbase: '50.0'
    k: '500.0'
    samp_rate: '44100'
    zeroDbV: Highzerodb
  states: {}
- name: customModule_PyVCA_0
  id: customModule_PyVCA
  parameters:
    expansion: expansion
  states: {}
- name: customModule_PyVCA_0_0
  id: customModule_PyVCA
  parameters:
    expansion: expansion
  states: {}
- name: customModule_PyVCA_0_0_0
  id: customModule_PyVCA
  parameters:
    expansion: expansion
  states: {}
- name: customModule_PyVCA_0_0_0_0
  id: customModule_PyVCA
  parameters:
    expansion: expansion
  states: {}
- name: customModule_PyVCA_0_0_0_0_0
  id: customModule_PyVCA
  parameters:
    expansion: expansion
  states: {}
- name: customModule_PyVCA_0_0_0_0_0_0
  id: customModule_PyVCA
  parameters:
    expansion: expansion
  states: {}
- name: customModule_midExpansion_0
  id: customModule_midExpansion
  parameters: {}
  states: {}
- name: customModule_myRMS_0_1
  id: customModule_myRMS
  parameters:
    Cbase: '3.63'
    Cdyn: '1'
    Idrain: '33'
    Rbase: '50'
    k: '500'
    samp_rate: '44100'
    zeroDbV: '1.2'
  states: {}
- name: customModule_white2pink_1
  id: customModule_white2pink
  parameters: {}
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: LowPassTaps
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: LowPassTaps
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: HighPassTaps
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: HighPassTaps
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '800'
    decim: '21'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '250'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Low"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"High"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Mid-band"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Output_R"'
    type: float
    ymax: '-30'
    ymin: '-90'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Low dB"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"High dB"'
    type: float
    update_time: '0.03'
  states: {}
- name: qtgui_number_sink_0_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    name: '"Mid dB"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Output"'
    size: int(samp_rate/2)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: int(samp_rate/2)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Input"'
    size: int(samp_rate/2)
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', customModule_white2pink_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_2, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', customModule_PyVCA_0, '1']
- [blocks_add_const_vxx_0, '0', customModule_PyVCA_0_0_0_0_0_0, '1']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_const_vxx_0_0, '0', customModule_PyVCA_0_0, '1']
- [blocks_add_const_vxx_0_0, '0', customModule_PyVCA_0_0_0_0_0, '1']
- [blocks_add_const_vxx_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_add_const_vxx_0_0_0, '0', customModule_PyVCA_0_0_0, '1']
- [blocks_add_const_vxx_0_0_0, '0', customModule_PyVCA_0_0_0_0, '1']
- [blocks_add_xx_0_1_0_0, '0', blocks_multiply_const_vxx_3_0, '0']
- [blocks_add_xx_0_1_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_add_xx_0_1_0_0_0, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_add_xx_0_2, '0', customModule_PyVCA_0_0_0, '0']
- [blocks_add_xx_0_2, '0', customModule_myRMS_0_1, '0']
- [blocks_add_xx_0_2, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_add_xx_0_2_0, '0', customModule_PyVCA_0_0_0_0, '0']
- [blocks_add_xx_0_2_0, '0', customModule_myRMS_0_1, '1']
- [blocks_delay_0, '0', blocks_add_xx_0_2, '2']
- [blocks_delay_0_0, '0', blocks_add_xx_0_2_0, '0']
- [blocks_delay_0_0_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_delay_0_0_0, '0', customModule_PyRMS_1, '0']
- [blocks_delay_0_0_0, '0', customModule_PyVCA_0_0, '0']
- [blocks_delay_0_0_0_0, '0', blocks_multiply_const_vxx_0_2_0, '0']
- [blocks_delay_0_0_0_0, '0', customModule_PyRMS_1, '1']
- [blocks_delay_0_0_0_0, '0', customModule_PyVCA_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', fir_filter_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_delay_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0_2_0, '2']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0_2, '1']
- [blocks_multiply_const_vxx_0_2_0, '0', blocks_add_xx_0_2_0, '1']
- [blocks_multiply_const_vxx_0_2_1, '0', blocks_add_xx_0_2, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_delay_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', fir_filter_xxx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', fir_filter_xxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', fir_filter_xxx_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_multiply_const_vxx_3, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_3_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_3_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_number_sink_0_2, '0']
- [blocks_multiply_xx_0_0_0, '0', qtgui_number_sink_0_3, '0']
- [blocks_repeat_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [customModule_PyRMS_0, '0', blocks_add_const_vxx_0, '0']
- [customModule_PyRMS_1, '0', blocks_add_const_vxx_0_0, '0']
- [customModule_PyVCA_0, '0', blocks_add_xx_0_1_0_0, '0']
- [customModule_PyVCA_0, '0', qtgui_time_sink_x_1_0, '0']
- [customModule_PyVCA_0_0, '0', blocks_add_xx_0_1_0_0, '1']
- [customModule_PyVCA_0_0_0, '0', blocks_add_xx_0_1_0_0, '2']
- [customModule_PyVCA_0_0_0_0, '0', blocks_add_xx_0_1_0_0_0, '0']
- [customModule_PyVCA_0_0_0_0_0, '0', blocks_add_xx_0_1_0_0_0, '1']
- [customModule_PyVCA_0_0_0_0_0_0, '0', blocks_add_xx_0_1_0_0_0, '2']
- [customModule_midExpansion_0, '0', blocks_repeat_0, '0']
- [customModule_myRMS_0_1, '0', low_pass_filter_0, '0']
- [customModule_white2pink_1, '0', blocks_multiply_const_vxx_1, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0_2_1, '0']
- [fir_filter_xxx_0, '0', customModule_PyRMS_0, '0']
- [fir_filter_xxx_0, '0', customModule_PyVCA_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [fir_filter_xxx_0_0, '0', customModule_PyRMS_0, '1']
- [fir_filter_xxx_0_0, '0', customModule_PyVCA_0_0_0_0_0_0, '0']
- [fir_filter_xxx_1, '0', blocks_delay_0_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_delay_0_0_0_0, '0']
- [low_pass_filter_0, '0', customModule_midExpansion_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
